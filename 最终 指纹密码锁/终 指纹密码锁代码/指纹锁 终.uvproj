# Keil uVision project 指纹锁 终.uvproj, settings and files
target Target 1 (MCS-51)
  device: 80/87C52 Intel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 指纹锁 终 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51
    ../10.14终/: buzz.c delay.c FPM10A.c i2c.c kaisuo.c key.c lcd_1602.c main.c uart.c buzz.h delay.h FPM10A.h i2c.h kaisuo.h key.h lcd_1602.h uart.h
